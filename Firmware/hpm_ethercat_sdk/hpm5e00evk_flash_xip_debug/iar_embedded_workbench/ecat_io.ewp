# IAR project ecat_io.ewp, settings and files
configuration Debug (RISCV, debug)
  General.GDeviceSelect: HPM5E31xGNx HPMicro HPM5E31xGNx
  General.GHeapSize: 0x4000
  ICCRISCV.IccLang: 2
  ICCRISCV.CCOptLevel: 1
  ICCRISCV.CCOptStrategy: 2
  ICCRISCV.CCExtraOptions: --diag_suppress Pa089; --diag_suppress Pe236; --diag_suppress Pe188; --diag_suppress Pe546; --diag_suppress Pe111
  ICCRISCV.CCDefines: FLASH_XIP=1; HPMSOC_HAS_HPMSDK_GPIO=y; HPMSOC_HAS_HPMSDK_TFA=y; HPMSOC_HAS_HPMSDK_PLIC=y; HPMSOC_HAS_HPMSDK_MCHTMR=y; HPMSOC_HAS_HPMSDK_PLICSW=y; HPMSOC_HAS_HPMSDK_GPTMR=y; HPMSOC_HAS_HPMSDK_OWR=y; HPMSOC_HAS_HPMSDK_EUI=y; HPMSOC_HAS_HPMSDK_UART=y; HPMSOC_HAS_HPMSDK_I2C=y; HPMSOC_HAS_HPMSDK_SPI=y; HPMSOC_HAS_HPMSDK_CRC=y; HPMSOC_HAS_HPMSDK_TSNS=y; HPMSOC_HAS_HPMSDK_MBX=y; HPMSOC_HAS_HPMSDK_EWDG=y; HPMSOC_HAS_HPMSDK_DMAMUX=y; HPMSOC_HAS_HPMSDK_DMAV2=y; HPMSOC_HAS_HPMSDK_PPI=y; HPMSOC_HAS_HPMSDK_GPIOM=y; HPMSOC_HAS_HPMSDK_LOBS=y; HPMSOC_HAS_HPMSDK_ADC16=y; HPMSOC_HAS_HPMSDK_ACMP=y; HPMSOC_HAS_HPMSDK_MCAN=y; HPMSOC_HAS_HPMSDK_PTPC=y; HPMSOC_HAS_HPMSDK_QEIV2=y; HPMSOC_HAS_HPMSDK_QEOV2=y; HPMSOC_HAS_HPMSDK_PWMV2=y; HPMSOC_HAS_HPMSDK_SDM=y; HPMSOC_HAS_HPMSDK_PLB=y; HPMSOC_HAS_HPMSDK_SYNT=y; HPMSOC_HAS_HPMSDK_TRGM=y; HPMSOC_HAS_HPMSDK_ENET=y; HPMSOC_HAS_HPMSDK_USB=y; HPMSOC_HAS_HPMSDK_ESC=y; HPMSOC_HAS_HPMSDK_OTP=y; HPMSOC_HAS_HPMSDK_SYSCTL=y; HPMSOC_HAS_HPMSDK_IOC=y; HPMSOC_HAS_HPMSDK_PLLCTLV2=y; HPMSOC_HAS_HPMSDK_PPOR=y; HPMSOC_HAS_HPMSDK_PCFG=y; HPMSOC_HAS_HPMSDK_PDGO=y; HPMSOC_HAS_HPMSDK_PGPR=y; HPMSOC_HAS_HPMSDK_HYBRID_XPI=y; HPMSOC_HAS_HPMSDK_PMP=y
  ICCRISCV.CCIncludePath2: ../../hpm_sdk_localized_for_hpm5e00evk/arch; ../../hpm_sdk_localized_for_hpm5e00evk/arch/riscv/l1c; ../../hpm_sdk_localized_for_hpm5e00evk/boards/hpm5e00evk; ../../hpm_sdk_localized_for_hpm5e00evk/soc/HPM5E00/HPM5E31; ../../hpm_sdk_localized_for_hpm5e00evk/soc/HPM5E00/ip; ../../hpm_sdk_localized_for_hpm5e00evk/soc/HPM5E00/HPM5E31/toolchains; ../../hpm_sdk_localized_for_hpm5e00evk/soc/HPM5E00/HPM5E31/boot; ../../hpm_sdk_localized_for_hpm5e00evk/drivers/inc; ../../hpm_sdk_localized_for_hpm5e00evk/utils; ../../hpm_sdk_localized_for_hpm5e00evk/components/debug_console; ../../hpm_sdk_localized_for_hpm5e00evk/components/eeprom_emulation; ../../hpm_sdk_localized_for_hpm5e00evk/components/eeprom_emulation/port; ../build_tmp/generated/include; ../../SSC/Src; ../../../port; ../..
  IASMRISCV.AsmIncludePath: as above
  OBJCOPY.OOCOutputFile: demo.bin
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkOutputFile: demo.elf
  ILINK.IlinkConfigDefines: _flash_size=1M
  ILINK.IlinkIcfFile: ..\..\hpm_sdk_localized_for_hpm5e00evk\soc\HPM5E00\HPM5E31\toolchains\iar\flash_xip.icf
  ILINK.IlinkProgramEntryLabel: _start
configuration Release (RISCV)
  as the first configuration, except:
  ICCRISCV.CCDefines: FLASH_XIP=1; HPMSOC_HAS_HPMSDK_GPIO=y; HPMSOC_HAS_HPMSDK_TFA=y; HPMSOC_HAS_HPMSDK_PLIC=y; HPMSOC_HAS_HPMSDK_MCHTMR=y; HPMSOC_HAS_HPMSDK_PLICSW=y; HPMSOC_HAS_HPMSDK_GPTMR=y; HPMSOC_HAS_HPMSDK_OWR=y; HPMSOC_HAS_HPMSDK_EUI=y; HPMSOC_HAS_HPMSDK_UART=y; HPMSOC_HAS_HPMSDK_I2C=y; HPMSOC_HAS_HPMSDK_SPI=y; HPMSOC_HAS_HPMSDK_CRC=y; HPMSOC_HAS_HPMSDK_TSNS=y; HPMSOC_HAS_HPMSDK_MBX=y; HPMSOC_HAS_HPMSDK_EWDG=y; HPMSOC_HAS_HPMSDK_DMAMUX=y; HPMSOC_HAS_HPMSDK_DMAV2=y; HPMSOC_HAS_HPMSDK_PPI=y; HPMSOC_HAS_HPMSDK_GPIOM=y; HPMSOC_HAS_HPMSDK_LOBS=y; HPMSOC_HAS_HPMSDK_ADC16=y; HPMSOC_HAS_HPMSDK_ACMP=y; HPMSOC_HAS_HPMSDK_MCAN=y; HPMSOC_HAS_HPMSDK_PTPC=y; HPMSOC_HAS_HPMSDK_QEIV2=y; HPMSOC_HAS_HPMSDK_QEOV2=y; HPMSOC_HAS_HPMSDK_PWMV2=y; HPMSOC_HAS_HPMSDK_SDM=y; HPMSOC_HAS_HPMSDK_PLB=y; HPMSOC_HAS_HPMSDK_SYNT=y; HPMSOC_HAS_HPMSDK_TRGM=y; HPMSOC_HAS_HPMSDK_ENET=y; HPMSOC_HAS_HPMSDK_USB=y; HPMSOC_HAS_HPMSDK_ESC=y; HPMSOC_HAS_HPMSDK_OTP=y; HPMSOC_HAS_HPMSDK_SYSCTL=y; HPMSOC_HAS_HPMSDK_IOC=y; HPMSOC_HAS_HPMSDK_PLLCTLV2=y; HPMSOC_HAS_HPMSDK_PPOR=y; HPMSOC_HAS_HPMSDK_PCFG=y; HPMSOC_HAS_HPMSDK_PDGO=y; HPMSOC_HAS_HPMSDK_PGPR=y; HPMSOC_HAS_HPMSDK_HYBRID_XPI=y; HPMSOC_HAS_HPMSDK_PMP=y; NDEBUG
  group application
    C:/sdk_env_v1.10.1/sdk_env_v1.10.0/hpm_sdk/samples/ethercat/ecat_io/: ecat.c
  group application/SSC/Src
    C:/sdk_env_v1.10.1/sdk_env_v1.10.0/hpm_sdk/samples/ethercat/ecat_io/SSC/Src/: coeappl.c ecatappl.c ecatcoe.c ecatslv.c mailbox.c objdef.c sdoserv.c
  group application/sdk_env_v1.10.1/sdk_env_v1.10.0/hpm_sdk/samples/ethercat/port
    C:/sdk_env_v1.10.1/sdk_env_v1.10.0/hpm_sdk/samples/ethercat/port/: hpm_ecat_hw.c hpm_ecat_phy.c hpm_ecat_e2p_emulation.c
  group application/application
    C:/sdk_env_v1.10.1/sdk_env_v1.10.0/hpm_sdk/samples/ethercat/ecat_io/application/: digital_io.c
  group soc/HPM5E00/HPM5E31
    ../../hpm_sdk_localized_for_hpm5e00evk/soc/HPM5E00/HPM5E31/: system.c hpm_sysctl_drv.c hpm_clock_drv.c hpm_otp_drv.c hpm_pdgo_drv.c hpm_trgm_soc_drv.c
  group soc/HPM5E00/HPM5E31/toolchains
    ../../hpm_sdk_localized_for_hpm5e00evk/soc/HPM5E00/HPM5E31/toolchains/: reset.c trap.c reset.c trap.c
  group soc/HPM5E00/HPM5E31/toolchains/iar
    ../../hpm_sdk_localized_for_hpm5e00evk/soc/HPM5E00/HPM5E31/toolchains/iar/: startup.s
  group soc/HPM5E00/HPM5E31/boot
    ../../hpm_sdk_localized_for_hpm5e00evk/soc/HPM5E00/HPM5E31/boot/: hpm_bootheader.c
  group arch/riscv/l1c
    ../../hpm_sdk_localized_for_hpm5e00evk/arch/riscv/l1c/: hpm_l1c_drv.c
  group boards/hpm5e00evk
    ../../hpm_sdk_localized_for_hpm5e00evk/boards/hpm5e00evk/: pinmux.c board.c
  group drivers/src
    ../../hpm_sdk_localized_for_hpm5e00evk/drivers/src/: hpm_uart_drv.c hpm_i2c_drv.c hpm_pmp_drv.c hpm_gpio_drv.c hpm_spi_drv.c hpm_gptmr_drv.c hpm_pwmv2_drv.c hpm_pllctlv2_drv.c hpm_usb_drv.c hpm_acmp_drv.c hpm_enet_drv.c hpm_adc16_drv.c hpm_pcfg_drv.c hpm_ptpc_drv.c hpm_mchtmr_drv.c hpm_tsns_drv.c hpm_crc_drv.c hpm_sdm_drv.c hpm_mcan_drv.c hpm_qeiv2_drv.c hpm_enc_pos_drv.c hpm_qeov2_drv.c hpm_dmav2_drv.c hpm_ewdg_drv.c hpm_plb_drv.c hpm_tfa_drv.S hpm_esc_drv.c hpm_ppi_drv.c hpm_lobs_drv.c hpm_eui_drv.c hpm_owr_drv.c
  group utils
    ../../hpm_sdk_localized_for_hpm5e00evk/utils/: hpm_sbrk.c hpm_swap.c hpm_ffssi.c hpm_crc32.c
  group components/debug_console
    ../../hpm_sdk_localized_for_hpm5e00evk/components/debug_console/: hpm_debug_console.c
  group components/eeprom_emulation
    ../../hpm_sdk_localized_for_hpm5e00evk/components/eeprom_emulation/: eeprom_emulation.c
  group components/eeprom_emulation/port
    ../../hpm_sdk_localized_for_hpm5e00evk/components/eeprom_emulation/port/: hpm_nor_flash.c
